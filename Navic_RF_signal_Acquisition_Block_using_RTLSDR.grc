options:
  parameters:
    author: udhay
    generate_options: qt_gui
    id: read
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ch_freq
  id: variable
  parameters:
    value: 1575.42e6
  states: {state: disabled}
- name: ch_freq
  id: variable
  parameters:
    value: 1176.42e6
  states: {}
- name: num_samp
  id: variable
  parameters:
    value: int(samp_rate*120)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /mnt/ukram/Navic_I_samp_120sec.bin
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /mnt/ukram/Navic_Q_samp_120sec.bin
    type: float
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: num_samp
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1e3
    type: complex
  states: {}
- name: correctiq_correctiq_0
  id: correctiq_correctiq
  parameters: {}
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Complex Corrected IQ seq in time"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Out I samp seq in time"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '10'
    ymin: '-10'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Out Q samp seq in time"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '10'
    ymin: '-10'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    ant0: '0'
    args: bias=0
    bb_gain0: '40'
    freq0: ch_freq
    gain0: '25'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_imag_0, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_file_sink_0_0, '0']
- [blocks_complex_to_imag_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_complex_to_real_0, '0', blocks_add_xx_0, '1']
- [blocks_complex_to_real_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_head_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_head_0, '0', correctiq_correctiq_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_complex_to_real_0, '0']
- [correctiq_correctiq_0, '0', blocks_multiply_const_xx_0, '0']
- [correctiq_correctiq_0, '0', qtgui_time_sink_x_0, '0']
- [rtlsdr_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
